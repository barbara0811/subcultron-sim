Commit message: aPad 3d model mesh fix

File: apad/data/simulation/apad.urdf (robot description, URDF)
Before this commit: robot pladypos, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=pladypos.osg
